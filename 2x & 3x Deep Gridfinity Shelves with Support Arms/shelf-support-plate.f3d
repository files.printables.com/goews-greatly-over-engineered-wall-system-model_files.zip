shelf-support-plate (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature" bodies "Support Mount"
named bodies: "Support Mount"