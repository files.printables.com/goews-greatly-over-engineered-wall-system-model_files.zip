shelf-support-arm (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature" bodies "Arm"
named bodies: "Arm"