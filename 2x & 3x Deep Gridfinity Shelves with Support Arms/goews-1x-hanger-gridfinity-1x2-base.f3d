goews-1x-hanger-gridfinity-1x2-base (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature"