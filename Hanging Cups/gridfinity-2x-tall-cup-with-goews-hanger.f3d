gridfinity-2x-tall-cup-with-goews-hanger (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature"