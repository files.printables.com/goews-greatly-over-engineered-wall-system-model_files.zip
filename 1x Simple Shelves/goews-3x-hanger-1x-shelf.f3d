goews-3x-hanger-1x-shelf (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Triple Plate Blank"