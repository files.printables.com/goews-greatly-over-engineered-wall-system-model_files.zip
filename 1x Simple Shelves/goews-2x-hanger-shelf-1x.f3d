goews-2x-hanger-shelf-1x (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Double Plate Blank"