goews-quad-hanger-gridfinity-1x4-base (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature" bodies "Quad Plate Blank"
named bodies: "Quad Plate Blank"