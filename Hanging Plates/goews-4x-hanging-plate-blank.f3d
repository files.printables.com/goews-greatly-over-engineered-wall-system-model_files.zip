goews-4x-hanging-plate-blank (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Quad Plate Blank"