goews-2x-hanging-plate-blank (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Double Plate Blank"