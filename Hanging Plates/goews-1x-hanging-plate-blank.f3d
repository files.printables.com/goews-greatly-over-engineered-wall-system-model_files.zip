goews-1x-hanging-plate-blank (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Single Plate Blank"