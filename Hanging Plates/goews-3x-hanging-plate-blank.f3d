goews-3x-hanging-plate-blank (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Triple Plate Blank"