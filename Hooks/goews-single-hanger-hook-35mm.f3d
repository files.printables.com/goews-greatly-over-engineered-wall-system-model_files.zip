goews-single-hanger-hook-35mm (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Single Plate Blank"