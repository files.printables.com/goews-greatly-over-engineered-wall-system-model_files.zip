goews-single-hanger-1xhole (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Single Plate Blank big hole"