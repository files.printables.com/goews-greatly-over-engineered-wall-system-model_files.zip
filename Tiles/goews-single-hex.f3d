goews-single-hex (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Hex"